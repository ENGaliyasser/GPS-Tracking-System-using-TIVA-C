# Keil uVision project GPS project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS project
  c flags: Optim=1
  c include: .\Utilities;.\MCAL\GPIO;.\MCAL\SYSTICK
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Utilities
    ./Utilities/: startup_TM4C123.s tm4c123gh6pm.h bitManipulation.h
  group MCAL
    ./MCAL/GPIO/: GPIO.h GPIO.c
    ./MCAL/UART/: UART.c UART.h
  group HAL
    ./HAL/GPS/: GPS.h GPS.c
    ./HAL/LED/: LED.C LED.h
    ./MCAL/SYSTICK/: Systick.c Systick.h
  group Application
    ./Application/: APP.c APP.h
